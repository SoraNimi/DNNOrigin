.measure tran avgvall0bl0 AVG v(l0bl0) FROM = 199ns TO =200ns
.measure tran avgvall0bl1 AVG v(l0bl1) FROM = 199ns TO =200ns
.measure tran avgvall0bl2 AVG v(l0bl2) FROM = 199ns TO =200ns
.measure tran avgvall0bl3 AVG v(l0bl3) FROM = 199ns TO =200ns
.measure tran avgvall0bl4 AVG v(l0bl4) FROM = 199ns TO =200ns
.measure tran avgvall0bl5 AVG v(l0bl5) FROM = 199ns TO =200ns
.measure tran avgvall0bl6 AVG v(l0bl6) FROM = 199ns TO =200ns
.measure tran avgvall0bl7 AVG v(l0bl7) FROM = 199ns TO =200ns
.measure tran avgvall0bl8 AVG v(l0bl8) FROM = 199ns TO =200ns
.measure tran avgvall0bl9 AVG v(l0bl9) FROM = 199ns TO =200ns
.measure tran avgvall0bl10 AVG v(l0bl10) FROM = 199ns TO =200ns
.measure tran avgvall0bl11 AVG v(l0bl11) FROM = 199ns TO =200ns
.measure tran avgvall0bl12 AVG v(l0bl12) FROM = 199ns TO =200ns
.measure tran avgvall0bl13 AVG v(l0bl13) FROM = 199ns TO =200ns
.measure tran avgvall0bl14 AVG v(l0bl14) FROM = 199ns TO =200ns
.measure tran avgvall0bl15 AVG v(l0bl15) FROM = 199ns TO =200ns
.measure tran avgvall0bl16 AVG v(l0bl16) FROM = 199ns TO =200ns
.measure tran avgvall0bl17 AVG v(l0bl17) FROM = 199ns TO =200ns
.measure tran avgvall0bl18 AVG v(l0bl18) FROM = 199ns TO =200ns
.measure tran avgvall0bl19 AVG v(l0bl19) FROM = 199ns TO =200ns
.measure tran avgvall0bl20 AVG v(l0bl20) FROM = 199ns TO =200ns
.measure tran avgvall0bl21 AVG v(l0bl21) FROM = 199ns TO =200ns
.measure tran avgvall0bl22 AVG v(l0bl22) FROM = 199ns TO =200ns
.measure tran avgvall0bl23 AVG v(l0bl23) FROM = 199ns TO =200ns
.measure tran avgvall0bl24 AVG v(l0bl24) FROM = 199ns TO =200ns
.measure tran avgvall0bl25 AVG v(l0bl25) FROM = 199ns TO =200ns
.measure tran avgvall0bl26 AVG v(l0bl26) FROM = 199ns TO =200ns
.measure tran avgvall0bl27 AVG v(l0bl27) FROM = 199ns TO =200ns
.measure tran avgvall0bl28 AVG v(l0bl28) FROM = 199ns TO =200ns
.measure tran avgvall0bl29 AVG v(l0bl29) FROM = 199ns TO =200ns
.measure tran avgvall0bl30 AVG v(l0bl30) FROM = 199ns TO =200ns
.measure tran avgvall0bl31 AVG v(l0bl31) FROM = 199ns TO =200ns
.measure tran avgvall0bl32 AVG v(l0bl32) FROM = 199ns TO =200ns
.measure tran avgvall0bl33 AVG v(l0bl33) FROM = 199ns TO =200ns
.measure tran avgvall0bl34 AVG v(l0bl34) FROM = 199ns TO =200ns
.measure tran avgvall0bl35 AVG v(l0bl35) FROM = 199ns TO =200ns
.measure tran avgvall0bl36 AVG v(l0bl36) FROM = 199ns TO =200ns
.measure tran avgvall0bl37 AVG v(l0bl37) FROM = 199ns TO =200ns
.measure tran avgvall0bl38 AVG v(l0bl38) FROM = 199ns TO =200ns
.measure tran avgvall0bl39 AVG v(l0bl39) FROM = 199ns TO =200ns
.measure tran avgvall0bl40 AVG v(l0bl40) FROM = 199ns TO =200ns
.measure tran avgvall0bl41 AVG v(l0bl41) FROM = 199ns TO =200ns
.measure tran avgvall0bl42 AVG v(l0bl42) FROM = 199ns TO =200ns
.measure tran avgvall0bl43 AVG v(l0bl43) FROM = 199ns TO =200ns
.measure tran avgvall0bl44 AVG v(l0bl44) FROM = 199ns TO =200ns
.measure tran avgvall0bl45 AVG v(l0bl45) FROM = 199ns TO =200ns
.measure tran avgvall0bl46 AVG v(l0bl46) FROM = 199ns TO =200ns
.measure tran avgvall0bl47 AVG v(l0bl47) FROM = 199ns TO =200ns
.measure tran avgvall0bl48 AVG v(l0bl48) FROM = 199ns TO =200ns
.measure tran avgvall0bl49 AVG v(l0bl49) FROM = 199ns TO =200ns
.measure tran avgvall0bl50 AVG v(l0bl50) FROM = 199ns TO =200ns
.measure tran avgvall0bl51 AVG v(l0bl51) FROM = 199ns TO =200ns
.measure tran avgvall0bl52 AVG v(l0bl52) FROM = 199ns TO =200ns
.measure tran avgvall0bl53 AVG v(l0bl53) FROM = 199ns TO =200ns
.measure tran avgvall0bl54 AVG v(l0bl54) FROM = 199ns TO =200ns
.measure tran avgvall0bl55 AVG v(l0bl55) FROM = 199ns TO =200ns
.measure tran avgvall0bl56 AVG v(l0bl56) FROM = 199ns TO =200ns
.measure tran avgvall0bl57 AVG v(l0bl57) FROM = 199ns TO =200ns
.measure tran avgvall0bl58 AVG v(l0bl58) FROM = 199ns TO =200ns
.measure tran avgvall0bl59 AVG v(l0bl59) FROM = 199ns TO =200ns
.measure tran avgvall0bl60 AVG v(l0bl60) FROM = 199ns TO =200ns
.measure tran avgvall0bl61 AVG v(l0bl61) FROM = 199ns TO =200ns
.measure tran avgvall0bl62 AVG v(l0bl62) FROM = 199ns TO =200ns
.measure tran avgvall0bl63 AVG v(l0bl63) FROM = 199ns TO =200ns
.measure tran avgvall0bl64 AVG v(l0bl64) FROM = 199ns TO =200ns
.measure tran avgvall0bl65 AVG v(l0bl65) FROM = 199ns TO =200ns
.measure tran avgvall0bl66 AVG v(l0bl66) FROM = 199ns TO =200ns
.measure tran avgvall0bl67 AVG v(l0bl67) FROM = 199ns TO =200ns
.measure tran avgvall0bl68 AVG v(l0bl68) FROM = 199ns TO =200ns
.measure tran avgvall0bl69 AVG v(l0bl69) FROM = 199ns TO =200ns
.measure tran avgvall0bl70 AVG v(l0bl70) FROM = 199ns TO =200ns
.measure tran avgvall0bl71 AVG v(l0bl71) FROM = 199ns TO =200ns
.measure tran avgvall0bl72 AVG v(l0bl72) FROM = 199ns TO =200ns
.measure tran avgvall0bl73 AVG v(l0bl73) FROM = 199ns TO =200ns
.measure tran avgvall0bl74 AVG v(l0bl74) FROM = 199ns TO =200ns
.measure tran avgvall0bl75 AVG v(l0bl75) FROM = 199ns TO =200ns
.measure tran avgvall0bl76 AVG v(l0bl76) FROM = 199ns TO =200ns
.measure tran avgvall0bl77 AVG v(l0bl77) FROM = 199ns TO =200ns
.measure tran avgvall0bl78 AVG v(l0bl78) FROM = 199ns TO =200ns
.measure tran avgvall0bl79 AVG v(l0bl79) FROM = 199ns TO =200ns
.measure tran avgvall0bl80 AVG v(l0bl80) FROM = 199ns TO =200ns
.measure tran avgvall0bl81 AVG v(l0bl81) FROM = 199ns TO =200ns
.measure tran avgvall0bl82 AVG v(l0bl82) FROM = 199ns TO =200ns
.measure tran avgvall0bl83 AVG v(l0bl83) FROM = 199ns TO =200ns
.measure tran avgvall0bl84 AVG v(l0bl84) FROM = 199ns TO =200ns
.measure tran avgvall0bl85 AVG v(l0bl85) FROM = 199ns TO =200ns
.measure tran avgvall0bl86 AVG v(l0bl86) FROM = 199ns TO =200ns
.measure tran avgvall0bl87 AVG v(l0bl87) FROM = 199ns TO =200ns
.measure tran avgvall0bl88 AVG v(l0bl88) FROM = 199ns TO =200ns
.measure tran avgvall0bl89 AVG v(l0bl89) FROM = 199ns TO =200ns
.measure tran avgvall0bl90 AVG v(l0bl90) FROM = 199ns TO =200ns
.measure tran avgvall0bl91 AVG v(l0bl91) FROM = 199ns TO =200ns
.measure tran avgvall0bl92 AVG v(l0bl92) FROM = 199ns TO =200ns
.measure tran avgvall0bl93 AVG v(l0bl93) FROM = 199ns TO =200ns
.measure tran avgvall0bl94 AVG v(l0bl94) FROM = 199ns TO =200ns
.measure tran avgvall0bl95 AVG v(l0bl95) FROM = 199ns TO =200ns
.measure tran avgvall0bl96 AVG v(l0bl96) FROM = 199ns TO =200ns
.measure tran avgvall0bl97 AVG v(l0bl97) FROM = 199ns TO =200ns
.measure tran avgvall0bl98 AVG v(l0bl98) FROM = 199ns TO =200ns
.measure tran avgvall0bl99 AVG v(l0bl99) FROM = 199ns TO =200ns
.measure tran avgvall0bl100 AVG v(l0bl100) FROM = 199ns TO =200ns
.measure tran avgvall0bl101 AVG v(l0bl101) FROM = 199ns TO =200ns
.measure tran avgvall0bl102 AVG v(l0bl102) FROM = 199ns TO =200ns
.measure tran avgvall0bl103 AVG v(l0bl103) FROM = 199ns TO =200ns
.measure tran avgvall0bl104 AVG v(l0bl104) FROM = 199ns TO =200ns
.measure tran avgvall0bl105 AVG v(l0bl105) FROM = 199ns TO =200ns
.measure tran avgvall0bl106 AVG v(l0bl106) FROM = 199ns TO =200ns
.measure tran avgvall0bl107 AVG v(l0bl107) FROM = 199ns TO =200ns
.measure tran avgvall0bl108 AVG v(l0bl108) FROM = 199ns TO =200ns
.measure tran avgvall0bl109 AVG v(l0bl109) FROM = 199ns TO =200ns
.measure tran avgvall0bl110 AVG v(l0bl110) FROM = 199ns TO =200ns
.measure tran avgvall0bl111 AVG v(l0bl111) FROM = 199ns TO =200ns
.measure tran avgvall0bl112 AVG v(l0bl112) FROM = 199ns TO =200ns
.measure tran avgvall0bl113 AVG v(l0bl113) FROM = 199ns TO =200ns
.measure tran avgvall0bl114 AVG v(l0bl114) FROM = 199ns TO =200ns
.measure tran avgvall0bl115 AVG v(l0bl115) FROM = 199ns TO =200ns
.measure tran avgvall0bl116 AVG v(l0bl116) FROM = 199ns TO =200ns
.measure tran avgvall0bl117 AVG v(l0bl117) FROM = 199ns TO =200ns
.measure tran avgvall0bl118 AVG v(l0bl118) FROM = 199ns TO =200ns
.measure tran avgvall0bl119 AVG v(l0bl119) FROM = 199ns TO =200ns
.measure tran avgvall0bl120 AVG v(l0bl120) FROM = 199ns TO =200ns
.measure tran avgvall0bl121 AVG v(l0bl121) FROM = 199ns TO =200ns
.measure tran avgvall0bl122 AVG v(l0bl122) FROM = 199ns TO =200ns
.measure tran avgvall0bl123 AVG v(l0bl123) FROM = 199ns TO =200ns
.measure tran avgvall0bl124 AVG v(l0bl124) FROM = 199ns TO =200ns
.measure tran avgvall0bl125 AVG v(l0bl125) FROM = 199ns TO =200ns
.measure tran avgvall0bl126 AVG v(l0bl126) FROM = 199ns TO =200ns
.measure tran avgvall0bl127 AVG v(l0bl127) FROM = 199ns TO =200ns
.measure tran avgvall0bl128 AVG v(l0bl128) FROM = 199ns TO =200ns
.measure tran avgvall0bl129 AVG v(l0bl129) FROM = 199ns TO =200ns
.measure tran avgvall0bl130 AVG v(l0bl130) FROM = 199ns TO =200ns
.measure tran avgvall0bl131 AVG v(l0bl131) FROM = 199ns TO =200ns
.measure tran avgvall0bl132 AVG v(l0bl132) FROM = 199ns TO =200ns
.measure tran avgvall0bl133 AVG v(l0bl133) FROM = 199ns TO =200ns
.measure tran avgvall0bl134 AVG v(l0bl134) FROM = 199ns TO =200ns
.measure tran avgvall0bl135 AVG v(l0bl135) FROM = 199ns TO =200ns
.measure tran avgvall0bl136 AVG v(l0bl136) FROM = 199ns TO =200ns
.measure tran avgvall0bl137 AVG v(l0bl137) FROM = 199ns TO =200ns
.measure tran avgvall0bl138 AVG v(l0bl138) FROM = 199ns TO =200ns
.measure tran avgvall0bl139 AVG v(l0bl139) FROM = 199ns TO =200ns
.measure tran avgvall0bl140 AVG v(l0bl140) FROM = 199ns TO =200ns
.measure tran avgvall0bl141 AVG v(l0bl141) FROM = 199ns TO =200ns
.measure tran avgvall0bl142 AVG v(l0bl142) FROM = 199ns TO =200ns
.measure tran avgvall0bl143 AVG v(l0bl143) FROM = 199ns TO =200ns
.measure tran avgvall0bl144 AVG v(l0bl144) FROM = 199ns TO =200ns
.measure tran avgvall0bl145 AVG v(l0bl145) FROM = 199ns TO =200ns
.measure tran avgvall0bl146 AVG v(l0bl146) FROM = 199ns TO =200ns
.measure tran avgvall0bl147 AVG v(l0bl147) FROM = 199ns TO =200ns
.measure tran avgvall0bl148 AVG v(l0bl148) FROM = 199ns TO =200ns
.measure tran avgvall0bl149 AVG v(l0bl149) FROM = 199ns TO =200ns
.measure tran avgvall0bl150 AVG v(l0bl150) FROM = 199ns TO =200ns
.measure tran avgvall0bl151 AVG v(l0bl151) FROM = 199ns TO =200ns
.measure tran avgvall0bl152 AVG v(l0bl152) FROM = 199ns TO =200ns
.measure tran avgvall0bl153 AVG v(l0bl153) FROM = 199ns TO =200ns
.measure tran avgvall0bl154 AVG v(l0bl154) FROM = 199ns TO =200ns
.measure tran avgvall0bl155 AVG v(l0bl155) FROM = 199ns TO =200ns
.measure tran avgvall0bl156 AVG v(l0bl156) FROM = 199ns TO =200ns
.measure tran avgvall0bl157 AVG v(l0bl157) FROM = 199ns TO =200ns
.measure tran avgvall0bl158 AVG v(l0bl158) FROM = 199ns TO =200ns
.measure tran avgvall0bl159 AVG v(l0bl159) FROM = 199ns TO =200ns
.measure tran avgvall0bl160 AVG v(l0bl160) FROM = 199ns TO =200ns
.measure tran avgvall0bl161 AVG v(l0bl161) FROM = 199ns TO =200ns
.measure tran avgvall0bl162 AVG v(l0bl162) FROM = 199ns TO =200ns
.measure tran avgvall0bl163 AVG v(l0bl163) FROM = 199ns TO =200ns
.measure tran avgvall0bl164 AVG v(l0bl164) FROM = 199ns TO =200ns
.measure tran avgvall0bl165 AVG v(l0bl165) FROM = 199ns TO =200ns
.measure tran avgvall0bl166 AVG v(l0bl166) FROM = 199ns TO =200ns
.measure tran avgvall0bl167 AVG v(l0bl167) FROM = 199ns TO =200ns
.measure tran avgvall0bl168 AVG v(l0bl168) FROM = 199ns TO =200ns
.measure tran avgvall0bl169 AVG v(l0bl169) FROM = 199ns TO =200ns
.measure tran avgvall0bl170 AVG v(l0bl170) FROM = 199ns TO =200ns
.measure tran avgvall0bl171 AVG v(l0bl171) FROM = 199ns TO =200ns
.measure tran avgvall0bl172 AVG v(l0bl172) FROM = 199ns TO =200ns
.measure tran avgvall0bl173 AVG v(l0bl173) FROM = 199ns TO =200ns
.measure tran avgvall0bl174 AVG v(l0bl174) FROM = 199ns TO =200ns
.measure tran avgvall0bl175 AVG v(l0bl175) FROM = 199ns TO =200ns
.measure tran avgvall0bl176 AVG v(l0bl176) FROM = 199ns TO =200ns
.measure tran avgvall0bl177 AVG v(l0bl177) FROM = 199ns TO =200ns
.measure tran avgvall0bl178 AVG v(l0bl178) FROM = 199ns TO =200ns
.measure tran avgvall0bl179 AVG v(l0bl179) FROM = 199ns TO =200ns
.measure tran avgvall0bl180 AVG v(l0bl180) FROM = 199ns TO =200ns
.measure tran avgvall0bl181 AVG v(l0bl181) FROM = 199ns TO =200ns
.measure tran avgvall0bl182 AVG v(l0bl182) FROM = 199ns TO =200ns
.measure tran avgvall0bl183 AVG v(l0bl183) FROM = 199ns TO =200ns
.measure tran avgvall0bl184 AVG v(l0bl184) FROM = 199ns TO =200ns
.measure tran avgvall0bl185 AVG v(l0bl185) FROM = 199ns TO =200ns
.measure tran avgvall0bl186 AVG v(l0bl186) FROM = 199ns TO =200ns
.measure tran avgvall0bl187 AVG v(l0bl187) FROM = 199ns TO =200ns
.measure tran avgvall0bl188 AVG v(l0bl188) FROM = 199ns TO =200ns
.measure tran avgvall0bl189 AVG v(l0bl189) FROM = 199ns TO =200ns
.measure tran avgvall0bl190 AVG v(l0bl190) FROM = 199ns TO =200ns
.measure tran avgvall0bl191 AVG v(l0bl191) FROM = 199ns TO =200ns
.measure tran avgvall0bl192 AVG v(l0bl192) FROM = 199ns TO =200ns
.measure tran avgvall0bl193 AVG v(l0bl193) FROM = 199ns TO =200ns
.measure tran avgvall0bl194 AVG v(l0bl194) FROM = 199ns TO =200ns
.measure tran avgvall0bl195 AVG v(l0bl195) FROM = 199ns TO =200ns
.measure tran avgvall0bl196 AVG v(l0bl196) FROM = 199ns TO =200ns
.measure tran avgvall0bl197 AVG v(l0bl197) FROM = 199ns TO =200ns
.measure tran avgvall0bl198 AVG v(l0bl198) FROM = 199ns TO =200ns
.measure tran avgvall0bl199 AVG v(l0bl199) FROM = 199ns TO =200ns
.measure tran avgvall0bl200 AVG v(l0bl200) FROM = 199ns TO =200ns
.measure tran avgvall0bl201 AVG v(l0bl201) FROM = 199ns TO =200ns
.measure tran avgvall0bl202 AVG v(l0bl202) FROM = 199ns TO =200ns
.measure tran avgvall0bl203 AVG v(l0bl203) FROM = 199ns TO =200ns
.measure tran avgvall0bl204 AVG v(l0bl204) FROM = 199ns TO =200ns
.measure tran avgvall0bl205 AVG v(l0bl205) FROM = 199ns TO =200ns
.measure tran avgvall0bl206 AVG v(l0bl206) FROM = 199ns TO =200ns
.measure tran avgvall0bl207 AVG v(l0bl207) FROM = 199ns TO =200ns
.measure tran avgvall0bl208 AVG v(l0bl208) FROM = 199ns TO =200ns
.measure tran avgvall0bl209 AVG v(l0bl209) FROM = 199ns TO =200ns
.measure tran avgvall0bl210 AVG v(l0bl210) FROM = 199ns TO =200ns
.measure tran avgvall0bl211 AVG v(l0bl211) FROM = 199ns TO =200ns
.measure tran avgvall0bl212 AVG v(l0bl212) FROM = 199ns TO =200ns
.measure tran avgvall0bl213 AVG v(l0bl213) FROM = 199ns TO =200ns
.measure tran avgvall0bl214 AVG v(l0bl214) FROM = 199ns TO =200ns
.measure tran avgvall0bl215 AVG v(l0bl215) FROM = 199ns TO =200ns
.measure tran avgvall0bl216 AVG v(l0bl216) FROM = 199ns TO =200ns
.measure tran avgvall0bl217 AVG v(l0bl217) FROM = 199ns TO =200ns
.measure tran avgvall0bl218 AVG v(l0bl218) FROM = 199ns TO =200ns
.measure tran avgvall0bl219 AVG v(l0bl219) FROM = 199ns TO =200ns
.measure tran avgvall0bl220 AVG v(l0bl220) FROM = 199ns TO =200ns
.measure tran avgvall0bl221 AVG v(l0bl221) FROM = 199ns TO =200ns
.measure tran avgvall0bl222 AVG v(l0bl222) FROM = 199ns TO =200ns
.measure tran avgvall0bl223 AVG v(l0bl223) FROM = 199ns TO =200ns
.measure tran avgvall0bl224 AVG v(l0bl224) FROM = 199ns TO =200ns
.measure tran avgvall0bl225 AVG v(l0bl225) FROM = 199ns TO =200ns
.measure tran avgvall0bl226 AVG v(l0bl226) FROM = 199ns TO =200ns
.measure tran avgvall0bl227 AVG v(l0bl227) FROM = 199ns TO =200ns
.measure tran avgvall0bl228 AVG v(l0bl228) FROM = 199ns TO =200ns
.measure tran avgvall0bl229 AVG v(l0bl229) FROM = 199ns TO =200ns
.measure tran avgvall0bl230 AVG v(l0bl230) FROM = 199ns TO =200ns
.measure tran avgvall0bl231 AVG v(l0bl231) FROM = 199ns TO =200ns
.measure tran avgvall0bl232 AVG v(l0bl232) FROM = 199ns TO =200ns
.measure tran avgvall0bl233 AVG v(l0bl233) FROM = 199ns TO =200ns
.measure tran avgvall0bl234 AVG v(l0bl234) FROM = 199ns TO =200ns
.measure tran avgvall0bl235 AVG v(l0bl235) FROM = 199ns TO =200ns
.measure tran avgvall0bl236 AVG v(l0bl236) FROM = 199ns TO =200ns
.measure tran avgvall0bl237 AVG v(l0bl237) FROM = 199ns TO =200ns
.measure tran avgvall0bl238 AVG v(l0bl238) FROM = 199ns TO =200ns
.measure tran avgvall0bl239 AVG v(l0bl239) FROM = 199ns TO =200ns
.measure tran avgvall0bl240 AVG v(l0bl240) FROM = 199ns TO =200ns
.measure tran avgvall0bl241 AVG v(l0bl241) FROM = 199ns TO =200ns
.measure tran avgvall0bl242 AVG v(l0bl242) FROM = 199ns TO =200ns
.measure tran avgvall0bl243 AVG v(l0bl243) FROM = 199ns TO =200ns
.measure tran avgvall0bl244 AVG v(l0bl244) FROM = 199ns TO =200ns
.measure tran avgvall0bl245 AVG v(l0bl245) FROM = 199ns TO =200ns
.measure tran avgvall0bl246 AVG v(l0bl246) FROM = 199ns TO =200ns
.measure tran avgvall0bl247 AVG v(l0bl247) FROM = 199ns TO =200ns
.measure tran avgvall0bl248 AVG v(l0bl248) FROM = 199ns TO =200ns
.measure tran avgvall0bl249 AVG v(l0bl249) FROM = 199ns TO =200ns
.measure tran avgvall0bl250 AVG v(l0bl250) FROM = 199ns TO =200ns
.measure tran avgvall0bl251 AVG v(l0bl251) FROM = 199ns TO =200ns
.measure tran avgvall0bl252 AVG v(l0bl252) FROM = 199ns TO =200ns
.measure tran avgvall0bl253 AVG v(l0bl253) FROM = 199ns TO =200ns
.measure tran avgvall0bl254 AVG v(l0bl254) FROM = 199ns TO =200ns
.measure tran avgvall0bl255 AVG v(l0bl255) FROM = 199ns TO =200ns
.measure tran avgvall0bl256 AVG v(l0bl256) FROM = 199ns TO =200ns
.measure tran avgvall0bl257 AVG v(l0bl257) FROM = 199ns TO =200ns
.measure tran avgvall0bl258 AVG v(l0bl258) FROM = 199ns TO =200ns
.measure tran avgvall0bl259 AVG v(l0bl259) FROM = 199ns TO =200ns
.measure tran avgvall0bl260 AVG v(l0bl260) FROM = 199ns TO =200ns
.measure tran avgvall0bl261 AVG v(l0bl261) FROM = 199ns TO =200ns
.measure tran avgvall0bl262 AVG v(l0bl262) FROM = 199ns TO =200ns
.measure tran avgvall0bl263 AVG v(l0bl263) FROM = 199ns TO =200ns
.measure tran avgvall0bl264 AVG v(l0bl264) FROM = 199ns TO =200ns
.measure tran avgvall0bl265 AVG v(l0bl265) FROM = 199ns TO =200ns
.measure tran avgvall0bl266 AVG v(l0bl266) FROM = 199ns TO =200ns
.measure tran avgvall0bl267 AVG v(l0bl267) FROM = 199ns TO =200ns
.measure tran avgvall0bl268 AVG v(l0bl268) FROM = 199ns TO =200ns
.measure tran avgvall0bl269 AVG v(l0bl269) FROM = 199ns TO =200ns
.measure tran avgvall0bl270 AVG v(l0bl270) FROM = 199ns TO =200ns
.measure tran avgvall0bl271 AVG v(l0bl271) FROM = 199ns TO =200ns
.measure tran avgvall0bl272 AVG v(l0bl272) FROM = 199ns TO =200ns
.measure tran avgvall0bl273 AVG v(l0bl273) FROM = 199ns TO =200ns
.measure tran avgvall0bl274 AVG v(l0bl274) FROM = 199ns TO =200ns
.measure tran avgvall0bl275 AVG v(l0bl275) FROM = 199ns TO =200ns
.measure tran avgvall0bl276 AVG v(l0bl276) FROM = 199ns TO =200ns
.measure tran avgvall0bl277 AVG v(l0bl277) FROM = 199ns TO =200ns
.measure tran avgvall0bl278 AVG v(l0bl278) FROM = 199ns TO =200ns
.measure tran avgvall0bl279 AVG v(l0bl279) FROM = 199ns TO =200ns
.measure tran avgvall0bl280 AVG v(l0bl280) FROM = 199ns TO =200ns
.measure tran avgvall0bl281 AVG v(l0bl281) FROM = 199ns TO =200ns
.measure tran avgvall0bl282 AVG v(l0bl282) FROM = 199ns TO =200ns
.measure tran avgvall0bl283 AVG v(l0bl283) FROM = 199ns TO =200ns
.measure tran avgvall0bl284 AVG v(l0bl284) FROM = 199ns TO =200ns
.measure tran avgvall0bl285 AVG v(l0bl285) FROM = 199ns TO =200ns
.measure tran avgvall0bl286 AVG v(l0bl286) FROM = 199ns TO =200ns
.measure tran avgvall0bl287 AVG v(l0bl287) FROM = 199ns TO =200ns
.measure tran avgvall0bl288 AVG v(l0bl288) FROM = 199ns TO =200ns
.measure tran avgvall0bl289 AVG v(l0bl289) FROM = 199ns TO =200ns
.measure tran avgvall0bl290 AVG v(l0bl290) FROM = 199ns TO =200ns
.measure tran avgvall0bl291 AVG v(l0bl291) FROM = 199ns TO =200ns
.measure tran avgvall0bl292 AVG v(l0bl292) FROM = 199ns TO =200ns
.measure tran avgvall0bl293 AVG v(l0bl293) FROM = 199ns TO =200ns
.measure tran avgvall0bl294 AVG v(l0bl294) FROM = 199ns TO =200ns
.measure tran avgvall0bl295 AVG v(l0bl295) FROM = 199ns TO =200ns
.measure tran avgvall0bl296 AVG v(l0bl296) FROM = 199ns TO =200ns
.measure tran avgvall0bl297 AVG v(l0bl297) FROM = 199ns TO =200ns
.measure tran avgvall0bl298 AVG v(l0bl298) FROM = 199ns TO =200ns
.measure tran avgvall0bl299 AVG v(l0bl299) FROM = 199ns TO =200ns
.measure tran avgvall0bl300 AVG v(l0bl300) FROM = 199ns TO =200ns
.measure tran avgvall0bl301 AVG v(l0bl301) FROM = 199ns TO =200ns
.measure tran avgvall0bl302 AVG v(l0bl302) FROM = 199ns TO =200ns
.measure tran avgvall0bl303 AVG v(l0bl303) FROM = 199ns TO =200ns
.measure tran avgvall0bl304 AVG v(l0bl304) FROM = 199ns TO =200ns
.measure tran avgvall0bl305 AVG v(l0bl305) FROM = 199ns TO =200ns
.measure tran avgvall0bl306 AVG v(l0bl306) FROM = 199ns TO =200ns
.measure tran avgvall0bl307 AVG v(l0bl307) FROM = 199ns TO =200ns
.measure tran avgvall0bl308 AVG v(l0bl308) FROM = 199ns TO =200ns
.measure tran avgvall0bl309 AVG v(l0bl309) FROM = 199ns TO =200ns
.measure tran avgvall0bl310 AVG v(l0bl310) FROM = 199ns TO =200ns
.measure tran avgvall0bl311 AVG v(l0bl311) FROM = 199ns TO =200ns
.measure tran avgvall0bl312 AVG v(l0bl312) FROM = 199ns TO =200ns
.measure tran avgvall0bl313 AVG v(l0bl313) FROM = 199ns TO =200ns
.measure tran avgvall0bl314 AVG v(l0bl314) FROM = 199ns TO =200ns
.measure tran avgvall0bl315 AVG v(l0bl315) FROM = 199ns TO =200ns
.measure tran avgvall0bl316 AVG v(l0bl316) FROM = 199ns TO =200ns
.measure tran avgvall0bl317 AVG v(l0bl317) FROM = 199ns TO =200ns
.measure tran avgvall0bl318 AVG v(l0bl318) FROM = 199ns TO =200ns
.measure tran avgvall0bl319 AVG v(l0bl319) FROM = 199ns TO =200ns
.measure tran avgvall0bl320 AVG v(l0bl320) FROM = 199ns TO =200ns
.measure tran avgvall0bl321 AVG v(l0bl321) FROM = 199ns TO =200ns
.measure tran avgvall0bl322 AVG v(l0bl322) FROM = 199ns TO =200ns
.measure tran avgvall0bl323 AVG v(l0bl323) FROM = 199ns TO =200ns
.measure tran avgvall0bl324 AVG v(l0bl324) FROM = 199ns TO =200ns
.measure tran avgvall0bl325 AVG v(l0bl325) FROM = 199ns TO =200ns
.measure tran avgvall0bl326 AVG v(l0bl326) FROM = 199ns TO =200ns
.measure tran avgvall0bl327 AVG v(l0bl327) FROM = 199ns TO =200ns
.measure tran avgvall0bl328 AVG v(l0bl328) FROM = 199ns TO =200ns
.measure tran avgvall0bl329 AVG v(l0bl329) FROM = 199ns TO =200ns
.measure tran avgvall0bl330 AVG v(l0bl330) FROM = 199ns TO =200ns
.measure tran avgvall0bl331 AVG v(l0bl331) FROM = 199ns TO =200ns
.measure tran avgvall0bl332 AVG v(l0bl332) FROM = 199ns TO =200ns
.measure tran avgvall0bl333 AVG v(l0bl333) FROM = 199ns TO =200ns
.measure tran avgvall0bl334 AVG v(l0bl334) FROM = 199ns TO =200ns
.measure tran avgvall0bl335 AVG v(l0bl335) FROM = 199ns TO =200ns
.measure tran avgvall0bl336 AVG v(l0bl336) FROM = 199ns TO =200ns
.measure tran avgvall0bl337 AVG v(l0bl337) FROM = 199ns TO =200ns
.measure tran avgvall0bl338 AVG v(l0bl338) FROM = 199ns TO =200ns
.measure tran avgvall0bl339 AVG v(l0bl339) FROM = 199ns TO =200ns
.measure tran avgvall0bl340 AVG v(l0bl340) FROM = 199ns TO =200ns
.measure tran avgvall0bl341 AVG v(l0bl341) FROM = 199ns TO =200ns
.measure tran avgvall0bl342 AVG v(l0bl342) FROM = 199ns TO =200ns
.measure tran avgvall0bl343 AVG v(l0bl343) FROM = 199ns TO =200ns
.measure tran avgvall0bl344 AVG v(l0bl344) FROM = 199ns TO =200ns
.measure tran avgvall0bl345 AVG v(l0bl345) FROM = 199ns TO =200ns
.measure tran avgvall0bl346 AVG v(l0bl346) FROM = 199ns TO =200ns
.measure tran avgvall0bl347 AVG v(l0bl347) FROM = 199ns TO =200ns
.measure tran avgvall0bl348 AVG v(l0bl348) FROM = 199ns TO =200ns
.measure tran avgvall0bl349 AVG v(l0bl349) FROM = 199ns TO =200ns
.measure tran avgvall0bl350 AVG v(l0bl350) FROM = 199ns TO =200ns
.measure tran avgvall0bl351 AVG v(l0bl351) FROM = 199ns TO =200ns
.measure tran avgvall0bl352 AVG v(l0bl352) FROM = 199ns TO =200ns
.measure tran avgvall0bl353 AVG v(l0bl353) FROM = 199ns TO =200ns
.measure tran avgvall0bl354 AVG v(l0bl354) FROM = 199ns TO =200ns
.measure tran avgvall0bl355 AVG v(l0bl355) FROM = 199ns TO =200ns
.measure tran avgvall0bl356 AVG v(l0bl356) FROM = 199ns TO =200ns
.measure tran avgvall0bl357 AVG v(l0bl357) FROM = 199ns TO =200ns
.measure tran avgvall0bl358 AVG v(l0bl358) FROM = 199ns TO =200ns
.measure tran avgvall0bl359 AVG v(l0bl359) FROM = 199ns TO =200ns
.measure tran avgvall0bl360 AVG v(l0bl360) FROM = 199ns TO =200ns
.measure tran avgvall0bl361 AVG v(l0bl361) FROM = 199ns TO =200ns
.measure tran avgvall0bl362 AVG v(l0bl362) FROM = 199ns TO =200ns
.measure tran avgvall0bl363 AVG v(l0bl363) FROM = 199ns TO =200ns
.measure tran avgvall0bl364 AVG v(l0bl364) FROM = 199ns TO =200ns
.measure tran avgvall0bl365 AVG v(l0bl365) FROM = 199ns TO =200ns
.measure tran avgvall0bl366 AVG v(l0bl366) FROM = 199ns TO =200ns
.measure tran avgvall0bl367 AVG v(l0bl367) FROM = 199ns TO =200ns
.measure tran avgvall0bl368 AVG v(l0bl368) FROM = 199ns TO =200ns
.measure tran avgvall0bl369 AVG v(l0bl369) FROM = 199ns TO =200ns
.measure tran avgvall0bl370 AVG v(l0bl370) FROM = 199ns TO =200ns
.measure tran avgvall0bl371 AVG v(l0bl371) FROM = 199ns TO =200ns
.measure tran avgvall0bl372 AVG v(l0bl372) FROM = 199ns TO =200ns
.measure tran avgvall0bl373 AVG v(l0bl373) FROM = 199ns TO =200ns
.measure tran avgvall0bl374 AVG v(l0bl374) FROM = 199ns TO =200ns
.measure tran avgvall0bl375 AVG v(l0bl375) FROM = 199ns TO =200ns
.measure tran avgvall0bl376 AVG v(l0bl376) FROM = 199ns TO =200ns
.measure tran avgvall0bl377 AVG v(l0bl377) FROM = 199ns TO =200ns
.measure tran avgvall0bl378 AVG v(l0bl378) FROM = 199ns TO =200ns
.measure tran avgvall0bl379 AVG v(l0bl379) FROM = 199ns TO =200ns
.measure tran avgvall0bl380 AVG v(l0bl380) FROM = 199ns TO =200ns
.measure tran avgvall0bl381 AVG v(l0bl381) FROM = 199ns TO =200ns
.measure tran avgvall0bl382 AVG v(l0bl382) FROM = 199ns TO =200ns
.measure tran avgvall0bl383 AVG v(l0bl383) FROM = 199ns TO =200ns
.measure tran avgvall0bl384 AVG v(l0bl384) FROM = 199ns TO =200ns
.measure tran avgvall0bl385 AVG v(l0bl385) FROM = 199ns TO =200ns
.measure tran avgvall0bl386 AVG v(l0bl386) FROM = 199ns TO =200ns
.measure tran avgvall0bl387 AVG v(l0bl387) FROM = 199ns TO =200ns
.measure tran avgvall0bl388 AVG v(l0bl388) FROM = 199ns TO =200ns
.measure tran avgvall0bl389 AVG v(l0bl389) FROM = 199ns TO =200ns
.measure tran avgvall0bl390 AVG v(l0bl390) FROM = 199ns TO =200ns
.measure tran avgvall0bl391 AVG v(l0bl391) FROM = 199ns TO =200ns
.measure tran avgvall0bl392 AVG v(l0bl392) FROM = 199ns TO =200ns
.measure tran avgvall0bl393 AVG v(l0bl393) FROM = 199ns TO =200ns
.measure tran avgvall0bl394 AVG v(l0bl394) FROM = 199ns TO =200ns
.measure tran avgvall0bl395 AVG v(l0bl395) FROM = 199ns TO =200ns
.measure tran avgvall0bl396 AVG v(l0bl396) FROM = 199ns TO =200ns
.measure tran avgvall0bl397 AVG v(l0bl397) FROM = 199ns TO =200ns
.measure tran avgvall0bl398 AVG v(l0bl398) FROM = 199ns TO =200ns
.measure tran avgvall0bl399 AVG v(l0bl399) FROM = 199ns TO =200ns
.measure tran avgvall0bl400 AVG v(l0bl400) FROM = 199ns TO =200ns
.measure tran avgvall0bl401 AVG v(l0bl401) FROM = 199ns TO =200ns
.measure tran avgvall0bl402 AVG v(l0bl402) FROM = 199ns TO =200ns
.measure tran avgvall0bl403 AVG v(l0bl403) FROM = 199ns TO =200ns
.measure tran avgvall0bl404 AVG v(l0bl404) FROM = 199ns TO =200ns
.measure tran avgvall0bl405 AVG v(l0bl405) FROM = 199ns TO =200ns
.measure tran avgvall0bl406 AVG v(l0bl406) FROM = 199ns TO =200ns
.measure tran avgvall0bl407 AVG v(l0bl407) FROM = 199ns TO =200ns
.measure tran avgvall0bl408 AVG v(l0bl408) FROM = 199ns TO =200ns
.measure tran avgvall0bl409 AVG v(l0bl409) FROM = 199ns TO =200ns
.measure tran avgvall0bl410 AVG v(l0bl410) FROM = 199ns TO =200ns
.measure tran avgvall0bl411 AVG v(l0bl411) FROM = 199ns TO =200ns
.measure tran avgvall0bl412 AVG v(l0bl412) FROM = 199ns TO =200ns
.measure tran avgvall0bl413 AVG v(l0bl413) FROM = 199ns TO =200ns
.measure tran avgvall0bl414 AVG v(l0bl414) FROM = 199ns TO =200ns
.measure tran avgvall0bl415 AVG v(l0bl415) FROM = 199ns TO =200ns
.measure tran avgvall0bl416 AVG v(l0bl416) FROM = 199ns TO =200ns
.measure tran avgvall0bl417 AVG v(l0bl417) FROM = 199ns TO =200ns
.measure tran avgvall0bl418 AVG v(l0bl418) FROM = 199ns TO =200ns
.measure tran avgvall0bl419 AVG v(l0bl419) FROM = 199ns TO =200ns
.measure tran avgvall0bl420 AVG v(l0bl420) FROM = 199ns TO =200ns
.measure tran avgvall0bl421 AVG v(l0bl421) FROM = 199ns TO =200ns
.measure tran avgvall0bl422 AVG v(l0bl422) FROM = 199ns TO =200ns
.measure tran avgvall0bl423 AVG v(l0bl423) FROM = 199ns TO =200ns
.measure tran avgvall0bl424 AVG v(l0bl424) FROM = 199ns TO =200ns
.measure tran avgvall0bl425 AVG v(l0bl425) FROM = 199ns TO =200ns
.measure tran avgvall0bl426 AVG v(l0bl426) FROM = 199ns TO =200ns
.measure tran avgvall0bl427 AVG v(l0bl427) FROM = 199ns TO =200ns
.measure tran avgvall0bl428 AVG v(l0bl428) FROM = 199ns TO =200ns
.measure tran avgvall0bl429 AVG v(l0bl429) FROM = 199ns TO =200ns
.measure tran avgvall0bl430 AVG v(l0bl430) FROM = 199ns TO =200ns
.measure tran avgvall0bl431 AVG v(l0bl431) FROM = 199ns TO =200ns
.measure tran avgvall0bl432 AVG v(l0bl432) FROM = 199ns TO =200ns
.measure tran avgvall0bl433 AVG v(l0bl433) FROM = 199ns TO =200ns
.measure tran avgvall0bl434 AVG v(l0bl434) FROM = 199ns TO =200ns
.measure tran avgvall0bl435 AVG v(l0bl435) FROM = 199ns TO =200ns
.measure tran avgvall0bl436 AVG v(l0bl436) FROM = 199ns TO =200ns
.measure tran avgvall0bl437 AVG v(l0bl437) FROM = 199ns TO =200ns
.measure tran avgvall0bl438 AVG v(l0bl438) FROM = 199ns TO =200ns
.measure tran avgvall0bl439 AVG v(l0bl439) FROM = 199ns TO =200ns
.measure tran avgvall0bl440 AVG v(l0bl440) FROM = 199ns TO =200ns
.measure tran avgvall0bl441 AVG v(l0bl441) FROM = 199ns TO =200ns
.measure tran avgvall0bl442 AVG v(l0bl442) FROM = 199ns TO =200ns
.measure tran avgvall0bl443 AVG v(l0bl443) FROM = 199ns TO =200ns
.measure tran avgvall0bl444 AVG v(l0bl444) FROM = 199ns TO =200ns
.measure tran avgvall0bl445 AVG v(l0bl445) FROM = 199ns TO =200ns
.measure tran avgvall0bl446 AVG v(l0bl446) FROM = 199ns TO =200ns
.measure tran avgvall0bl447 AVG v(l0bl447) FROM = 199ns TO =200ns
.measure tran avgvall0bl448 AVG v(l0bl448) FROM = 199ns TO =200ns
.measure tran avgvall0bl449 AVG v(l0bl449) FROM = 199ns TO =200ns
.measure tran avgvall0bl450 AVG v(l0bl450) FROM = 199ns TO =200ns
.measure tran avgvall0bl451 AVG v(l0bl451) FROM = 199ns TO =200ns
.measure tran avgvall0bl452 AVG v(l0bl452) FROM = 199ns TO =200ns
.measure tran avgvall0bl453 AVG v(l0bl453) FROM = 199ns TO =200ns
.measure tran avgvall0bl454 AVG v(l0bl454) FROM = 199ns TO =200ns
.measure tran avgvall0bl455 AVG v(l0bl455) FROM = 199ns TO =200ns
.measure tran avgvall0bl456 AVG v(l0bl456) FROM = 199ns TO =200ns
.measure tran avgvall0bl457 AVG v(l0bl457) FROM = 199ns TO =200ns
.measure tran avgvall0bl458 AVG v(l0bl458) FROM = 199ns TO =200ns
.measure tran avgvall0bl459 AVG v(l0bl459) FROM = 199ns TO =200ns
.measure tran avgvall0bl460 AVG v(l0bl460) FROM = 199ns TO =200ns
.measure tran avgvall0bl461 AVG v(l0bl461) FROM = 199ns TO =200ns
.measure tran avgvall0bl462 AVG v(l0bl462) FROM = 199ns TO =200ns
.measure tran avgvall0bl463 AVG v(l0bl463) FROM = 199ns TO =200ns
.measure tran avgvall0bl464 AVG v(l0bl464) FROM = 199ns TO =200ns
.measure tran avgvall0bl465 AVG v(l0bl465) FROM = 199ns TO =200ns
.measure tran avgvall0bl466 AVG v(l0bl466) FROM = 199ns TO =200ns
.measure tran avgvall0bl467 AVG v(l0bl467) FROM = 199ns TO =200ns
.measure tran avgvall0bl468 AVG v(l0bl468) FROM = 199ns TO =200ns
.measure tran avgvall0bl469 AVG v(l0bl469) FROM = 199ns TO =200ns
.measure tran avgvall0bl470 AVG v(l0bl470) FROM = 199ns TO =200ns
.measure tran avgvall0bl471 AVG v(l0bl471) FROM = 199ns TO =200ns
.measure tran avgvall0bl472 AVG v(l0bl472) FROM = 199ns TO =200ns
.measure tran avgvall0bl473 AVG v(l0bl473) FROM = 199ns TO =200ns
.measure tran avgvall0bl474 AVG v(l0bl474) FROM = 199ns TO =200ns
.measure tran avgvall0bl475 AVG v(l0bl475) FROM = 199ns TO =200ns
.measure tran avgvall0bl476 AVG v(l0bl476) FROM = 199ns TO =200ns
.measure tran avgvall0bl477 AVG v(l0bl477) FROM = 199ns TO =200ns
.measure tran avgvall0bl478 AVG v(l0bl478) FROM = 199ns TO =200ns
.measure tran avgvall0bl479 AVG v(l0bl479) FROM = 199ns TO =200ns
.measure tran avgvall0bl480 AVG v(l0bl480) FROM = 199ns TO =200ns
.measure tran avgvall0bl481 AVG v(l0bl481) FROM = 199ns TO =200ns
.measure tran avgvall0bl482 AVG v(l0bl482) FROM = 199ns TO =200ns
.measure tran avgvall0bl483 AVG v(l0bl483) FROM = 199ns TO =200ns
.measure tran avgvall0bl484 AVG v(l0bl484) FROM = 199ns TO =200ns
.measure tran avgvall0bl485 AVG v(l0bl485) FROM = 199ns TO =200ns
.measure tran avgvall0bl486 AVG v(l0bl486) FROM = 199ns TO =200ns
.measure tran avgvall0bl487 AVG v(l0bl487) FROM = 199ns TO =200ns
.measure tran avgvall0bl488 AVG v(l0bl488) FROM = 199ns TO =200ns
.measure tran avgvall0bl489 AVG v(l0bl489) FROM = 199ns TO =200ns
.measure tran avgvall0bl490 AVG v(l0bl490) FROM = 199ns TO =200ns
.measure tran avgvall0bl491 AVG v(l0bl491) FROM = 199ns TO =200ns
.measure tran avgvall0bl492 AVG v(l0bl492) FROM = 199ns TO =200ns
.measure tran avgvall0bl493 AVG v(l0bl493) FROM = 199ns TO =200ns
.measure tran avgvall0bl494 AVG v(l0bl494) FROM = 199ns TO =200ns
.measure tran avgvall0bl495 AVG v(l0bl495) FROM = 199ns TO =200ns
.measure tran avgvall0bl496 AVG v(l0bl496) FROM = 199ns TO =200ns
.measure tran avgvall0bl497 AVG v(l0bl497) FROM = 199ns TO =200ns
.measure tran avgvall0bl498 AVG v(l0bl498) FROM = 199ns TO =200ns
.measure tran avgvall0bl499 AVG v(l0bl499) FROM = 199ns TO =200ns
.measure tran avgvall0bl500 AVG v(l0bl500) FROM = 199ns TO =200ns
.measure tran avgvall0bl501 AVG v(l0bl501) FROM = 199ns TO =200ns
.measure tran avgvall0bl502 AVG v(l0bl502) FROM = 199ns TO =200ns
.measure tran avgvall0bl503 AVG v(l0bl503) FROM = 199ns TO =200ns
.measure tran avgvall0bl504 AVG v(l0bl504) FROM = 199ns TO =200ns
.measure tran avgvall0bl505 AVG v(l0bl505) FROM = 199ns TO =200ns
.measure tran avgvall0bl506 AVG v(l0bl506) FROM = 199ns TO =200ns
.measure tran avgvall0bl507 AVG v(l0bl507) FROM = 199ns TO =200ns
.measure tran avgvall0bl508 AVG v(l0bl508) FROM = 199ns TO =200ns
.measure tran avgvall0bl509 AVG v(l0bl509) FROM = 199ns TO =200ns
.measure tran avgvall0bl510 AVG v(l0bl510) FROM = 199ns TO =200ns
.measure tran avgvall0bl511 AVG v(l0bl511) FROM = 199ns TO =200ns
